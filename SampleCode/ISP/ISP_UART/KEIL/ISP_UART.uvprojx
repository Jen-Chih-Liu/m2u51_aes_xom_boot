# Keil uVision project ISP_UART.uvprojx, settings and files
target ISP_UART (6220000::V6.22::ARMCLANG)
  device: M2U54KG6AE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M23") CLOCK(12000000) ESEL ELITTLE
  output: ISP_UART
  AfterMake: fromelf --bin ".\obj\ISP_UART.axf" --output ".\obj\bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=1
  c include: ..\..\..\..\Library\Device\Nuvoton\M2U51\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\CMSIS\Core\Include;..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\aprom_isp_0x0.scf
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2U51/Source/: system_M2U51.c
    ../: startup_M2U51_isp.c
  group User
    ../: fmc_user.c isp_user.c targetdev.c main.c uart_transfer.c
    ../../../../Library/StdDriver/src/: clk.c
    ./: aes_xom.c
